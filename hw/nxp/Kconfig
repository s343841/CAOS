## hw/nxp/Kconfig
```kconfig
config NXPEXP_MCU
    bool

config NXPEXAMPLE_BOARD
    bool
    select NXPEXP_MCU
```
